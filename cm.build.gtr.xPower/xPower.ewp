# IAR project xPower.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32G474QE ST STM32G474QE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_NUCLEO_64; USE_HAL_DRIVER; STM32G474xx
  ICCARM.CCIncludePath2: ../cm.3rd.bsw.gtr/Os/Source/CMSIS_RTOS/; ../cm.3rd.mcal.stm32.v130/Inc/; ../cm.app.usr.xPower/Api/; Stubs/; ../cm.build.gtr.xPower/CMSIS/Device/ST/STM32G4xx/Include/; ../cm.build.gtr.xPower/CMSIS/Include/; ../cm.build.gtr.xPower/Stubs/; ../cm.3rd.bsw.gtr/Os/Source/include/; ../cm.3rd.bsw.gtr/Os\Source/portable/IAR/ARM_CM4F/; ../cm.app.led.xPower/api/; ../cm.app.pushbutton.xPower/api/; ../cm.model.debugport.gtr/api/
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: Stubs/
  OBJCOPY.OOCOutputFile: xPower.srec
  ILINK.IlinkOutputFile: xPower.out
  ILINK.IlinkIcfFile: D:\stm32-g474\cm.build.gtr.xPower\stm32g474xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group cm.3rd.bsw.gtr/Os/Source
    ../cm.3rd.bsw.gtr/Os/Source/CMSIS_RTOS/: cmsis_os.c
    ../cm.3rd.bsw.gtr/Os/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../cm.3rd.bsw.gtr/Os/Source/portable/MemMang/: heap_4.c
    ../cm.3rd.bsw.gtr/Os/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group cm.3rd.mcal.stm32.v130/Src
    ../cm.3rd.mcal.stm32.v130/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group cm.app.led.xPower/src
    ../cm.app.led.xPower/src/: led.c
  group cm.app.pushbutton.xPower/src
    ../cm.app.pushbutton.xPower/src/: pushbutton.c
  group cm.app.usr.xPower/src
    ../cm.app.usr.xPower/Src/: BoardInfo.c
  group cm.build.gtr.xPower/StartUp
    ./: startup_stm32g474xx.s
  group cm.build.gtr.xPower/Stubs
    Stubs/: main.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c stm32g4xx_it.c system_stm32g4xx.c
  group cm.model.debugport.gtr/src
    ../cm.model.debugport.gtr/src/: debugport.c
